<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\AD&#x8F6C;&#x6362;.ewp</path>
  </project>
  <batchBuild/>
</workspace>


